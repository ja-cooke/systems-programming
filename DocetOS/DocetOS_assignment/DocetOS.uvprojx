# Keil uVision project DocetOS.uvprojx, settings and files
target STM32F407 Flash (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DocetOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  c misc: -Wno-declaration-after-statement -Wnon-gcc -Wshift-sign-overflow -Wpadded -Wmissing-variable-declarations -Wmissing-prototypes -Wvla
  c include: inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./src/: mode_utils.c main.c mode_utils_asm.s
    ./src/OS/: mutex.c
  group OS
    ./src/OS/: scheduler.c os.c os_asm.s sleep.c semaphore.c heap.c mempool.c queue.c static_alloc.c
    ./inc/OS/: static_alloc.h
  group System
    ./src/Utils/: hardfault.c utils.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:Startup 2.6.3
